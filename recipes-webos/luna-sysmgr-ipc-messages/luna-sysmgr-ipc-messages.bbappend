PRINC := "${@int(PRINC) + 1}"

inherit webos-ports-submissions

SRCREV = "0c9717ab949bb57757b2e6f7a5538b615bb4ca30"
